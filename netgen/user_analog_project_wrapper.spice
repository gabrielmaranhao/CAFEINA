* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper la_data_in[109] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_out[109] la_data_out[110] la_data_out[111] la_data_out[112]
+ la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116] la_data_out[117]
+ la_data_out[118] la_data_out[119] la_data_out[120] la_data_out[121] la_data_out[122]
+ la_data_out[123] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_oenb[108] la_oenb[109] la_oenb[110] la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114]
+ la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118] la_oenb[119] la_oenb[120] la_oenb[121]
+ la_oenb[122] la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] user_clock2
+ user_irq[0] user_irq[1] user_irq[2] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_out[88] la_data_out[89] la_data_out[90]
+ la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94] la_data_out[95]
+ la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99] la_oenb[100] la_oenb[101]
+ la_oenb[102] la_oenb[103] la_oenb[104] la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[98]
+ la_data_in[99] la_data_out[100] la_data_out[101] la_data_out[102] la_data_out[103]
+ la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107] la_data_out[108]
+ la_data_in[101] la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105]
+ la_data_in[106] la_data_in[107] la_data_in[108] la_data_in[100] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[88] la_data_in[89] la_data_in[90]
+ la_data_in[91] la_data_out[68] la_data_out[69] la_data_out[70] la_data_out[71] la_data_out[72]
+ la_data_out[73] la_data_out[74] la_data_out[75] la_data_out[76] la_data_out[77]
+ la_data_out[78] la_data_out[79] la_data_out[80] la_data_out[81] la_data_out[82]
+ la_data_out[83] la_data_out[84] la_data_out[85] la_data_out[86] la_data_out[87]
+ la_data_in[87] la_data_in[68] la_data_in[69] la_data_in[70] la_data_in[71] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72]
+ la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79]
+ la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86]
+ la_oenb[87] la_data_in[86] la_data_in[54] la_data_in[55] la_data_in[56] la_data_in[57]
+ la_data_in[58] la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65] la_oenb[66]
+ la_data_in[59] la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64]
+ la_data_in[65] la_data_in[66] la_data_in[67] la_data_out[65] la_data_out[66] la_data_out[67]
+ la_data_out[62] la_data_out[63] la_data_out[64] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_out[47] la_data_out[48]
+ la_data_out[49] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53]
+ la_data_out[54] la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58]
+ la_data_out[59] la_data_out[60] la_data_out[61] la_data_in[39] la_data_in[40] la_data_in[41]
+ la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29] la_data_out[30]
+ la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35]
+ la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33] la_oenb[34]
+ la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[40] la_oenb[41]
+ la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46] la_data_out[40] la_data_out[41]
+ la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45] la_data_out[46]
+ la_data_in[42] la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[30] la_data_in[31] la_data_in[32] la_data_in[33]
+ la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38] la_data_out[19]
+ la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_oenb[12] la_oenb[13]
+ la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[10] la_data_in[11]
+ la_data_in[8] la_data_in[10] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15]
+ la_oenb[6] la_data_in[16] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[9]
+ la_data_in[20] la_data_out[6] la_oenb[7] la_data_in[21] la_data_in[22] la_data_in[23]
+ la_data_in[24] la_data_in[25] la_data_in[26] la_data_out[24] la_data_out[10] la_data_out[25]
+ la_data_in[7] la_oenb[8] la_data_out[7] la_data_in[6] la_data_out[12] la_data_out[13]
+ la_data_out[14] la_data_out[9] la_data_out[15] la_data_out[16] la_data_out[11] la_oenb[9]
+ la_oenb[11] la_data_out[8] la_data_out[17] la_data_out[18] la_oenb[5] la_data_out[1]
+ la_data_in[0] la_data_out[0] la_data_in[2] la_data_in[1] la_oenb[2] la_data_in[5]
+ la_oenb[0] la_data_in[4] la_oenb[1] la_data_in[3] la_oenb[3] la_data_out[5] la_data_out[3]
+ la_data_out[4] la_data_out[2] la_oenb[4] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[30] wbs_adr_i[31] wbs_dat_i[17]
+ wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23]
+ wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29]
+ wbs_dat_i[30] wbs_dat_i[31] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19] wbs_dat_o[20]
+ wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26]
+ wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[30] wbs_dat_o[31] wbs_adr_i[1]
+ wbs_ack_o wbs_adr_i[0] wbs_dat_i[1] wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13]
+ wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[2] wb_clk_i wbs_dat_i[2]
+ wb_rst_i wbs_adr_i[3] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7]
+ wbs_dat_i[8] wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12]
+ wbs_dat_o[13] wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_adr_i[4] wbs_adr_i[5]
+ wbs_adr_i[6] wbs_dat_o[1] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0]
+ wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14] wbs_dat_o[2]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5] gpio_analog[6]
+ gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5] gpio_noesd[6] io_analog[1]
+ io_analog[2] io_analog[3] io_analog[4] io_clamp_high[0] io_clamp_low[0] io_in[10]
+ io_in[11] io_in[12] io_in[13] io_in[9] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[9] io_oeb[10] io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9]
+ io_out[10] io_out[11] io_out[12] io_out[13] io_out[9] vccd1 vdda1 io_in[17] gpio_analog[9]
+ gpio_noesd[10] gpio_noesd[7] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17]
+ io_analog[6] io_analog[7] io_analog[8] io_analog[9] io_oeb[14] io_oeb[15] io_oeb[16]
+ io_oeb[17] gpio_noesd[8] io_clamp_high[1] io_clamp_high[2] gpio_noesd[9] io_clamp_low[1]
+ io_out[14] io_out[15] io_out[16] io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10]
+ vccd2 gpio_analog[7] gpio_analog[8] io_in[14] io_in[15] vssa2 io_in[16] io_in_3v3[25]
+ io_in_3v3[26] gpio_analog[16] gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11]
+ io_in[18] io_in[19] io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21]
+ io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24]
+ io_in[25] io_in[26] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15]
+ io_out[18] io_out[19] io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25]
+ io_out[26] gpio_noesd[16] gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15]
+ io_in_3v3[18] io_in_3v3[19] vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ vssd2 io_in_3v3[24] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0]
+ io_in[2] io_in[3] io_in[4] io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8]
+ gpio_analog[0] io_oeb[1] io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6]
+ io_out[7] io_out[8] gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3]
+ io_in_3v3[4] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ vssd1 io_in_3v3[5] io_out[0] vssa1 io_analog[0] io_analog[5]
X0 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X4 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X5 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X6 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X7 io_analog[0] ina_top_0.VB1 a_435052_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X8 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X9 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X10 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X11 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X12 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X13 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X14 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X15 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X16 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X17 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X18 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X19 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X20 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X21 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X22 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X23 a_436278_532587# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X24 a_436278_531491# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X25 ina_top_0.VB1 ina_top_0.VB1 a_434536_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X26 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X27 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X28 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X29 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X30 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X31 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X32 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X33 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X34 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X35 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X36 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X37 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X38 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X39 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X40 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X41 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X42 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X43 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X44 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X45 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X46 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X47 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X48 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X49 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X50 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X51 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X52 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X53 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X54 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X55 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X56 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X57 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X58 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X59 io_analog[0] ina_top_0.VB1 a_435052_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X60 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X61 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X62 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X63 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X64 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X65 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X66 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X67 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X68 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X69 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X70 io_analog[0] ina_top_0.VB1 a_438020_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X71 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X72 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X73 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X74 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X75 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X76 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X77 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X78 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X79 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X80 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X81 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X82 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X83 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X84 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X85 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X86 io_analog[0] ina_top_0.VB1 a_435762_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X87 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X88 io_analog[0] ina_top_0.VB1 a_435762_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X89 ina_top_0.VB3 ina_top_0.VB1 a_434536_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X90 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X91 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X92 io_analog[0] ina_top_0.VB1 a_435052_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X93 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X94 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X95 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X96 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X97 a_435052_535042# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X98 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X99 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X100 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X101 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X102 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X103 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X104 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X105 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X106 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X107 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X108 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X109 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X110 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X111 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X112 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X113 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X114 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X115 ina_top_0.VB3 ina_top_0.VB1 a_434536_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X116 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X117 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X118 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X119 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X120 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X121 a_438020_533673# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X122 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X123 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X124 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X125 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X126 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X127 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X128 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X129 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X130 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X131 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X132 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X133 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X134 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X135 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X136 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X137 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X138 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X139 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X140 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X141 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X142 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X143 a_434536_529985# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X144 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X145 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X146 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X147 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X148 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X149 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X150 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X151 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X152 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X153 vssa1 ina_top_0.VB2 a_444594_531154# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X154 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X155 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X156 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X157 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X158 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X159 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X160 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X161 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X162 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X163 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X164 a_436278_534421# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X165 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X166 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X167 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X168 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X169 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X170 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X171 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X172 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X173 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X174 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X175 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X176 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X177 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X178 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X179 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X180 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X181 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X182 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X183 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X184 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X185 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X186 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X187 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X188 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X189 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X190 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X191 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X192 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X193 a_437504_537433# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X194 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X195 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X196 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X197 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X198 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X199 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X200 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X201 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X202 a_435052_531491# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X203 a_435052_532587# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X204 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X205 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X206 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X207 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X208 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X209 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X210 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X211 io_analog[0] ina_top_0.VB1 a_435762_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X212 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X213 a_437504_527864# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X214 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X215 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X216 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X217 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X218 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X219 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X220 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X221 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X222 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X223 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X224 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X225 a_436278_531958# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X226 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X227 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X228 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X229 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X230 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X231 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X232 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X233 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X234 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X235 io_analog[0] ina_top_0.VB1 a_436794_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X236 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X237 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X238 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X239 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X240 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X241 io_analog[0] ina_top_0.VB1 a_438020_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X242 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X243 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X244 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X245 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X246 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X247 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X248 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X249 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X250 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X251 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X252 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X253 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X254 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X255 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X256 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X257 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X258 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X259 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X260 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X261 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X262 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X263 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X264 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X265 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X266 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X267 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X268 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X269 io_analog[0] ina_top_0.VB1 a_435762_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X270 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X271 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X272 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X273 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X274 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X275 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X276 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X277 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X278 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X279 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X280 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X281 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X282 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X283 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X284 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X285 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X286 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X287 a_438020_529985# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X288 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X289 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X290 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X291 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X292 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X293 ina_top_0.dda_0.VD1 gpio_noesd[6] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X294 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X295 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X296 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X297 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X298 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X299 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X300 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X301 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X302 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X303 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X304 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X305 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X306 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X307 ina_top_0.VB3 ina_top_0.VB1 a_436278_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X308 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X309 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X310 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X311 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X312 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X313 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X314 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X315 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X316 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X317 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X318 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X319 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X320 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X321 a_435052_534421# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X322 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X323 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X324 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X325 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X326 vssa1 ina_top_0.VB2 a_441182_531154# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X327 ina_top_0.VB2 ina_top_0.VB1 a_436278_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X328 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X329 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X330 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X331 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X332 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X333 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X334 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X335 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X336 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X337 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X338 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X339 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X340 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X341 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X342 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X343 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X344 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X345 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X346 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X347 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X348 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X349 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X350 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X351 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X352 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X353 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X354 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X355 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X356 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X357 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X358 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X359 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X360 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X361 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X362 a_434536_533052# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X363 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X364 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X365 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X366 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X367 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X368 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X369 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X370 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X371 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X372 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X373 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X374 a_435762_528481# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X375 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X376 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X377 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X378 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X379 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X380 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X381 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X382 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X383 a_435052_531958# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X384 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X385 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X386 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X387 a_443569_537711# ina_top_0.VB4 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X388 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X389 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X390 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X391 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X392 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X393 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X394 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X395 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X396 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X397 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X398 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X399 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X400 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X401 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X402 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X403 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X404 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X405 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X406 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X407 io_analog[0] ina_top_0.VB1 a_436794_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X408 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X409 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X410 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X411 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X412 a_434536_536546# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X413 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X414 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X415 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X416 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X417 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X418 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X419 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X420 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X421 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X422 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X423 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X424 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X425 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X426 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X427 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X428 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X429 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X430 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X431 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X432 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X433 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X434 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X435 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X436 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X437 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X438 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X439 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X440 a_434536_530872# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X441 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X442 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X443 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X444 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X445 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X446 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X447 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X448 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X449 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X450 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X451 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X452 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X453 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X454 io_analog[0] ina_top_0.VB1 a_438020_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X455 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X456 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X457 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X458 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X459 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X460 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X461 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X462 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X463 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X464 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X465 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X466 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X467 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X468 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X469 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X470 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X471 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X472 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X473 gpio_noesd[6] ina_top_0.VB3 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X474 a_436278_529368# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X475 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X476 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X477 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X478 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X479 io_analog[0] ina_top_0.VB1 a_435052_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X480 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X481 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X482 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X483 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X484 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X485 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X486 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X487 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X488 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X489 ina_top_0.VB2 ina_top_0.VB1 a_434536_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X490 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X491 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X492 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X493 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X494 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X495 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X496 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X497 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X498 io_analog[0] ina_top_0.VB1 a_438020_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X499 a_438020_533052# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X500 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X501 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X502 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X503 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X504 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X505 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X506 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X507 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X508 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X509 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X510 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X511 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X512 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X513 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X514 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X515 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X516 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X517 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X518 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X519 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X520 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X521 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X522 io_analog[0] ina_top_0.VB1 a_435762_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X523 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X524 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X525 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X526 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X527 ina_top_0.VB1 io_analog[5] a_442035_531154# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X528 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X529 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X530 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X531 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X532 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X533 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X534 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X535 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X536 io_analog[0] ina_top_0.VB1 a_438020_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X537 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X538 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X539 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X540 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X541 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X542 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X543 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X544 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X545 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X546 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X547 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X548 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X549 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X550 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X551 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X552 a_438020_536546# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X553 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X554 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X555 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X556 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X557 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X558 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X559 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X560 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X561 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X562 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X563 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X564 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X565 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X566 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X567 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X568 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X569 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X570 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X571 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X572 a_438020_530872# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X573 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X574 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X575 a_436278_535929# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X576 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X577 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X578 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X579 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X580 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X581 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X582 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X583 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X584 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X585 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X586 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X587 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X588 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X589 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X590 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X591 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X592 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X593 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X594 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X595 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X596 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X597 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X598 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X599 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X600 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X601 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X602 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X603 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X604 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X605 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X606 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X607 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X608 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X609 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X610 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X611 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X612 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X613 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X614 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X615 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X616 io_analog[0] ina_top_0.VB1 a_436794_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X617 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X618 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X619 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X620 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X621 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X622 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X623 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X624 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X625 a_443741_531154# io_analog[5] vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X626 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X627 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X628 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X629 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X630 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X631 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X632 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X633 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X634 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X635 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X636 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X637 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X638 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X639 io_analog[0] ina_top_0.VB1 a_435762_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X640 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X641 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X642 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X643 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X644 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X645 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X646 a_435052_529368# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X647 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X648 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X649 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X650 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X651 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X652 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X653 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X654 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X655 a_435762_535042# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X656 a_443569_536177# ina_top_0.VB4 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X657 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X658 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X659 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X660 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X661 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X662 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X663 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X664 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X665 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X666 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X667 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X668 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X669 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X670 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X671 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X672 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X673 io_analog[0] ina_top_0.VB1 a_436794_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X674 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X675 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X676 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X677 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X678 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X679 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X680 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X681 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X682 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X683 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X684 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X685 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X686 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X687 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X688 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X689 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X690 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X691 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X692 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X693 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X694 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X695 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X696 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X697 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X698 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X699 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X700 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X701 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X702 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X703 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X704 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X705 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X706 io_analog[0] ina_top_0.VB1 a_436794_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X707 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X708 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X709 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X710 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X711 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X712 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X713 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X714 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X715 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X716 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X717 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X718 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X719 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X720 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X721 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X722 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X723 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X724 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X725 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X726 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X727 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X728 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X729 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X730 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X731 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X732 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X733 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X734 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X735 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X736 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X737 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X738 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X739 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X740 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X741 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X742 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X743 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X744 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X745 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X746 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X747 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X748 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X749 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X750 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X751 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X752 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X753 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X754 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X755 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X756 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X757 io_analog[0] ina_top_0.VB1 a_435052_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X758 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X759 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X760 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X761 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X762 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X763 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X764 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X765 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X766 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X767 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X768 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X769 a_435052_535929# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X770 a_435762_531491# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X771 a_435762_532587# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X772 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X773 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X774 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X775 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X776 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X777 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X778 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X779 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X780 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X781 a_444963_529247# ina_top_0.VB3 a_444705_529247# vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X782 ina_top_0.VB3 ina_top_0.VB1 a_434536_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X783 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X784 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X785 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X786 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X787 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X788 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X789 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X790 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X791 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X792 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X793 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X794 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X795 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X796 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X797 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X798 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X799 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X800 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X801 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X802 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X803 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X804 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X805 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X806 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X807 ina_top_0.VB1 ina_top_0.VB1 a_437504_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X808 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X809 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X810 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X811 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X812 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X813 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X814 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X815 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X816 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X817 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X818 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X819 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X820 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X821 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X822 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X823 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X824 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X825 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X826 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X827 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X828 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X829 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X830 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X831 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X832 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X833 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X834 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X835 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
D0 vssa1 io_analog[1] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X836 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X837 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X838 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X839 a_434536_528481# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X840 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X841 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X842 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X843 a_444594_531154# ina_top_0.VB2 ina_top_0.VB4 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X844 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X845 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X846 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X847 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X848 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X849 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X850 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X851 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X852 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X853 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X854 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X855 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X856 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X857 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X858 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X859 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X860 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X861 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X862 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X863 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X864 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X865 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X866 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X867 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X868 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X869 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X870 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X871 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X872 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X873 io_analog[0] ina_top_0.VB1 a_435052_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X874 io_analog[0] ina_top_0.VB1 a_435052_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X875 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X876 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X877 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X878 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X879 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X880 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X881 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X882 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X883 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X884 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X885 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X886 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X887 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X888 ina_top_0.VB4 ina_top_0.VB4 a_443827_536480# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X889 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X890 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X891 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X892 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X893 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X894 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X895 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X896 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X897 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X898 ina_top_0.VB1 ina_top_0.VB1 a_434536_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X899 ina_top_0.VB1 ina_top_0.VB1 a_434536_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X900 ina_top_0.dda_0.VIT_N2 gpio_noesd[5] ina_top_0.dda_0.VD2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X901 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X902 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X903 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X904 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X905 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X906 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X907 a_435762_534421# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X908 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X909 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X910 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X911 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X912 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X913 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X914 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X915 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X916 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X917 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X918 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X919 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X920 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X921 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X922 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X923 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X924 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X925 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X926 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X927 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X928 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X929 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X930 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X931 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X932 a_436794_533673# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X933 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X934 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X935 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
D1 vssa1 gpio_noesd[6] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X936 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X937 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X938 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X939 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X940 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X941 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X942 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X943 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X944 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X945 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X946 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X947 io_analog[0] ina_top_0.VB1 a_438020_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X948 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X949 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X950 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X951 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X952 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X953 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X954 vssa1 ina_top_0.VB2 a_442888_532060# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X955 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X956 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X957 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X958 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X959 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X960 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X961 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X962 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X963 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X964 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X965 a_435762_531958# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X966 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X967 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X968 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X969 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X970 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X971 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X972 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X973 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X974 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X975 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X976 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X977 ina_top_0.VB2 ina_top_0.VB1 a_437504_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X978 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X979 a_438020_528481# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X980 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X981 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X982 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X983 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X984 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X985 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X986 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X987 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X988 io_analog[0] ina_top_0.VB1 a_435052_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X989 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X990 a_436278_537433# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X991 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X992 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X993 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X994 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X995 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X996 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X997 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X998 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X999 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1000 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1001 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1002 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1003 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1004 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1005 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1006 ina_top_0.VB4 ina_top_0.VB4 a_443827_536944# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1007 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1008 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1009 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1010 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1011 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1012 ina_top_0.VB2 ina_top_0.VB1 a_434536_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1013 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1014 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1015 a_436278_527864# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1016 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1017 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1018 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1019 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1020 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1021 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1022 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1023 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1024 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1025 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1026 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1027 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1028 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1029 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1030 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1031 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1032 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1033 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1034 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1035 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1036 ina_top_0.dda_0.VD1 gpio_noesd[6] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1037 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1038 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1039 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1040 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1041 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1042 vssa1 io_analog[5] a_442888_533437# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1043 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1044 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1045 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1046 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1047 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1048 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1049 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1050 io_analog[0] ina_top_0.VB1 a_435762_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1051 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1052 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1053 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1054 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1055 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1056 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1057 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1058 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1059 io_analog[0] ina_top_0.VB1 a_435052_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1060 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1061 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1062 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1063 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1064 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1065 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1066 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1067 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1068 io_analog[0] ina_top_0.VB1 a_435762_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1069 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1070 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1071 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1072 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1073 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1074 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1075 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1076 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1077 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1078 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1079 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1080 ina_top_0.VB1 ina_top_0.VB1 a_434536_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1081 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1082 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1083 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1084 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1085 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1086 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1087 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1088 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1089 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1090 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1091 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1092 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1093 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1094 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1095 a_436794_529985# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1096 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1097 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1098 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1099 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1100 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1101 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1102 io_analog[0] ina_top_0.VB1 a_436794_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1103 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1104 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1105 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1106 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1107 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1108 a_444705_529247# ina_top_0.VB3 a_444447_529247# vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1109 a_434536_535042# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1110 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1111 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1112 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1113 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1114 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1115 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1116 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1117 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1118 gpio_noesd[6] ina_top_0.VB3 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1119 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1120 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1121 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1122 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1123 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1124 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1125 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1126 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1127 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1128 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1129 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1130 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1131 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1132 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1133 vssa1 io_analog[5] a_442888_532532# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1134 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1135 a_437504_533673# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1136 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1137 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1138 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1139 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1140 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1141 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1142 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1143 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1144 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1145 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1146 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1147 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1148 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1149 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1150 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1151 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1152 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1153 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1154 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1155 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1156 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1157 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1158 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1159 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1160 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1161 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1162 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1163 io_analog[5] io_analog[5] a_443741_532060# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1164 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1165 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1166 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1167 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1168 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1169 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1170 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1171 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1172 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1173 a_435052_537433# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1174 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1175 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1176 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1177 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1178 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1179 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1180 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1181 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1182 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1183 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1184 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1185 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1186 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1187 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1188 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1189 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1190 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1191 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1192 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1193 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1194 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1195 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1196 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1197 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1198 a_435052_527864# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1199 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1200 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1201 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1202 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1203 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1204 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1205 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1206 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1207 ina_top_0.VB1 ina_top_0.VB1 a_437504_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1208 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1209 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1210 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1211 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1212 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1213 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1214 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1215 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1216 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1217 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1218 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1219 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1220 io_analog[0] ina_top_0.VB1 a_438020_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1221 a_443827_536480# ina_top_0.VB4 a_443569_536480# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1222 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1223 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1224 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1225 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1226 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1227 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1228 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1229 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1230 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1231 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1232 a_434536_531491# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1233 a_434536_532587# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1234 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1235 a_435762_529368# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1236 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1237 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1238 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1239 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1240 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1241 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1242 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1243 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1244 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1245 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1246 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1247 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1248 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1249 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1250 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1251 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1252 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1253 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1254 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1255 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1256 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1257 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1258 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1259 ina_top_0.VB4 ina_top_0.VB2 a_443741_533437# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1260 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1261 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1262 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1263 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1264 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1265 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1266 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1267 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1268 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1269 ina_top_0.VB3 ina_top_0.VB1 a_437504_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1270 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1271 ina_top_0.VB1 ina_top_0.VB1 a_436278_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1272 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1273 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1274 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1275 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1276 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1277 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1278 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1279 a_438020_535042# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1280 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1281 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1282 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1283 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1284 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1285 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1286 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1287 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1288 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1289 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1290 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1291 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1292 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1293 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1294 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1295 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1296 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1297 ina_top_0.VB3 ina_top_0.VB1 a_437504_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1298 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1299 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1300 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1301 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1302 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1303 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1304 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1305 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1306 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1307 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1308 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1309 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1310 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1311 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1312 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1313 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1314 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1315 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1316 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1317 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1318 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1319 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1320 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1321 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1322 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1323 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1324 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1325 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1326 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1327 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1328 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1329 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1330 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1331 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1332 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1333 a_437504_529985# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1334 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1335 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1336 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1337 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1338 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1339 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1340 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1341 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1342 io_analog[0] ina_top_0.VB1 a_435052_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1343 io_analog[0] ina_top_0.VB1 a_438020_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1344 io_analog[0] ina_top_0.VB1 a_438020_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1345 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1346 a_436794_533052# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1347 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1348 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1349 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1350 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1351 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1352 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1353 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1354 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1355 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1356 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1357 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1358 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1359 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1360 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1361 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1362 a_435762_535929# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1363 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1364 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1365 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1366 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1367 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1368 ina_top_0.VB2 ina_top_0.VB2 a_443741_532532# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1369 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1370 ina_top_0.VB3 ina_top_0.VB1 a_434536_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1371 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1372 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1373 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1374 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1375 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1376 a_443827_536944# ina_top_0.VB4 a_443569_536944# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1377 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1378 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1379 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1380 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1381 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1382 a_434536_534421# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1383 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1384 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1385 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1386 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1387 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1388 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1389 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1390 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1391 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1392 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1393 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1394 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1395 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1396 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1397 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1398 a_438020_531491# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1399 a_438020_532587# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1400 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1401 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1402 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1403 a_436794_536546# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1404 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1405 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1406 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1407 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
D2 vssa1 gpio_noesd[4] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X1408 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1409 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1410 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1411 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1412 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1413 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1414 io_analog[0] ina_top_0.VB1 a_436794_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1415 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1416 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1417 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1418 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1419 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1420 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1421 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1422 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1423 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1424 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1425 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1426 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1427 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1428 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1429 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1430 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1431 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1432 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1433 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1434 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1435 a_436794_530872# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1436 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1437 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1438 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1439 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1440 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1441 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1442 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1443 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1444 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1445 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1446 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1447 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1448 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1449 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1450 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1451 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1452 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1453 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1454 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1455 a_434536_531958# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1456 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1457 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1458 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1459 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1460 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1461 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1462 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1463 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1464 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1465 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1466 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1467 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1468 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1469 ina_top_0.VB3 ina_top_0.VB1 a_436278_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1470 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1471 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1472 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1473 io_analog[0] ina_top_0.VB1 a_435052_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1474 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1475 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1476 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1477 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1478 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1479 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1480 a_442035_532060# io_analog[5] vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1481 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1482 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1483 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1484 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1485 ina_top_0.VB3 ina_top_0.VB3 a_444963_529247# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1486 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1487 io_analog[0] ina_top_0.VB1 a_438020_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1488 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1489 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1490 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1491 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1492 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1493 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1494 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1495 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1496 ina_top_0.VB2 ina_top_0.VB1 a_434536_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1497 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1498 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1499 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1500 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1501 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1502 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1503 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1504 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1505 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1506 ina_top_0.VB4 ina_top_0.VB4 a_443827_537247# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1507 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1508 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1509 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1510 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1511 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1512 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1513 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1514 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1515 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1516 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1517 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1518 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1519 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1520 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1521 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1522 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1523 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1524 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1525 io_analog[0] ina_top_0.VB1 a_436794_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1526 io_analog[0] ina_top_0.VB1 a_436794_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1527 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1528 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1529 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1530 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1531 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1532 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1533 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1534 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1535 a_438020_534421# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1536 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1537 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1538 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1539 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1540 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1541 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1542 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1543 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1544 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1545 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1546 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1547 io_analog[0] ina_top_0.VB1 a_438020_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1548 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1549 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1550 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1551 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1552 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1553 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1554 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1555 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1556 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1557 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1558 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1559 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1560 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1561 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1562 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1563 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1564 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1565 a_442035_533437# ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1566 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1567 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1568 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1569 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1570 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1571 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1572 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1573 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1574 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1575 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1576 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1577 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1578 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1579 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1580 a_437504_533052# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1581 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1582 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1583 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1584 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1585 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1586 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1587 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1588 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1589 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1590 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1591 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1592 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1593 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1594 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1595 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1596 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1597 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1598 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1599 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1600 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1601 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1602 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1603 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1604 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1605 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1606 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1607 a_438020_531958# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1608 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1609 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1610 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1611 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1612 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1613 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1614 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1615 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1616 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1617 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1618 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1619 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1620 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1621 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1622 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1623 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1624 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1625 a_437504_536546# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1626 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1627 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1628 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1629 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1630 a_441182_532060# ina_top_0.VB2 ina_top_0.VB2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1631 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1632 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1633 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1634 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1635 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1636 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1637 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1638 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1639 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1640 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1641 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1642 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1643 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1644 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1645 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1646 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1647 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1648 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1649 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1650 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1651 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1652 a_437504_530872# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1653 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1654 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1655 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1656 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1657 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1658 a_442035_532532# ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1659 io_analog[0] ina_top_0.VB1 a_436794_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1660 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1661 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1662 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1663 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1664 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1665 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1666 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1667 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1668 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1669 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1670 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1671 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1672 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1673 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1674 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1675 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1676 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1677 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1678 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1679 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1680 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1681 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1682 a_442888_532060# ina_top_0.VB2 ina_top_0.VB2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1683 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1684 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1685 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1686 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1687 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1688 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1689 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1690 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1691 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1692 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1693 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1694 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1695 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1696 ina_top_0.VB1 ina_top_0.VB1 a_436278_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1697 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1698 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1699 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1700 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1701 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1702 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1703 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1704 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1705 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1706 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1707 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1708 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1709 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1710 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1711 a_434536_529368# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1712 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1713 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1714 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1715 ina_top_0.VB2 ina_top_0.VB1 a_437504_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1716 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1717 a_441182_533437# io_analog[5] ina_top_0.VB1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1718 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1719 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1720 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1721 io_analog[0] ina_top_0.VB1 a_436794_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1722 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1723 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1724 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1725 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1726 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1727 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1728 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1729 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1730 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1731 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1732 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1733 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1734 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1735 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1736 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1737 ina_top_0.VB2 ina_top_0.VB1 a_436278_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1738 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1739 ina_top_0.dda_0.VIT_N2 gpio_noesd[5] ina_top_0.dda_0.VD2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1740 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1741 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1742 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1743 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1744 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1745 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1746 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1747 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1748 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1749 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1750 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1751 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1752 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1753 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1754 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1755 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1756 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1757 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1758 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1759 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1760 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1761 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1762 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1763 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1764 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1765 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1766 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1767 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1768 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1769 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1770 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1771 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1772 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1773 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1774 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1775 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1776 a_442888_533437# io_analog[5] ina_top_0.VB1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1777 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1778 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1779 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1780 ina_top_0.VB2 ina_top_0.VB1 a_436278_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1781 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1782 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1783 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1784 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1785 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1786 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1787 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1788 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1789 a_435762_537433# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
D3 vssa1 gpio_noesd[5] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X1790 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1791 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1792 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1793 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1794 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1795 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1796 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1797 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1798 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1799 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1800 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1801 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1802 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1803 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1804 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1805 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1806 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1807 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1808 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1809 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1810 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1811 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1812 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1813 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1814 a_435762_527864# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1815 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1816 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1817 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1818 a_441182_532532# io_analog[5] io_analog[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1819 io_analog[0] ina_top_0.VB1 a_438020_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1820 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1821 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1822 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1823 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1824 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1825 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1826 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1827 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1828 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1829 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1830 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1831 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1832 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1833 a_434536_535929# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1834 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1835 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1836 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1837 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1838 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1839 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1840 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1841 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1842 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1843 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1844 a_436794_528481# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1845 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1846 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1847 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1848 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1849 a_444447_529247# ina_top_0.VB3 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1850 a_443827_537247# ina_top_0.VB4 a_443569_537247# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1851 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1852 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1853 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1854 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1855 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1856 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1857 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1858 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1859 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1860 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1861 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1862 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1863 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1864 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1865 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1866 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1867 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1868 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1869 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1870 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1871 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1872 a_438020_529368# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1873 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1874 a_442888_532532# io_analog[5] io_analog[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1875 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1876 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1877 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1878 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1879 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1880 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1881 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1882 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1883 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1884 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1885 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1886 io_analog[0] ina_top_0.VB1 a_435052_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1887 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1888 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1889 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1890 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1891 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1892 ina_top_0.dda_0.VD1 gpio_noesd[6] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1893 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1894 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1895 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1896 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1897 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1898 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1899 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1900 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1901 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1902 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1903 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1904 io_analog[0] ina_top_0.VB1 a_435052_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1905 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1906 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1907 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1908 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1909 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1910 ina_top_0.VB2 ina_top_0.VB1 a_434536_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1911 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1912 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1913 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1914 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1915 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1916 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1917 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1918 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1919 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1920 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1921 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1922 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1923 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1924 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1925 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1926 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1927 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1928 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1929 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1930 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1931 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1932 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1933 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1934 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1935 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1936 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1937 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1938 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1939 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1940 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1941 ina_top_0.VB3 ina_top_0.VB1 a_434536_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1942 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1943 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1944 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1945 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1946 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1947 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1948 io_analog[0] ina_top_0.VB1 a_438020_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1949 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1950 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1951 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1952 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1953 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1954 a_443569_536480# ina_top_0.VB4 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1955 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1956 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1957 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1958 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1959 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1960 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1961 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1962 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1963 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1964 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1965 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1966 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1967 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1968 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1969 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1970 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1971 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1972 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1973 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1974 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1975 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1976 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1977 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1978 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1979 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1980 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1981 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1982 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1983 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1984 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1985 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1986 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1987 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1988 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1989 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1990 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X1991 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1992 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X1993 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X1994 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1995 a_438020_535929# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1996 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X1997 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1998 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X1999 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2000 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2001 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2002 io_analog[0] ina_top_0.VB1 a_436794_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2003 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2004 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2005 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2006 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2007 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2008 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2009 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2010 a_436278_533673# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2011 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2012 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2013 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2014 ina_top_0.VB3 ina_top_0.VB1 a_437504_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2015 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2016 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2017 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2018 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2019 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2020 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2021 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2022 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2023 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2024 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2025 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2026 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2027 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2028 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2029 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2030 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2031 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2032 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2033 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2034 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2035 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2036 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2037 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2038 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2039 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2040 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2041 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2042 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2043 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2044 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2045 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2046 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2047 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2048 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2049 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2050 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2051 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2052 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2053 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2054 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2055 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2056 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2057 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2058 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2059 io_analog[0] ina_top_0.VB1 a_435762_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2060 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2061 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2062 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2063 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2064 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2065 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2066 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2067 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2068 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2069 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2070 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2071 ina_top_0.dda_0.VD1 gpio_noesd[6] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2072 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2073 a_437504_528481# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2074 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2075 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2076 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2077 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2078 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2079 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2080 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2081 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2082 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2083 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2084 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2085 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2086 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2087 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2088 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2089 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2090 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2091 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2092 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2093 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2094 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2095 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2096 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2097 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2098 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2099 gpio_noesd[6] ina_top_0.VB3 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2100 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2101 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2102 a_443569_536944# ina_top_0.VB4 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2103 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2104 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2105 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2106 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2107 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2108 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2109 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2110 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2111 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2112 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2113 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2114 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2115 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2116 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2117 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2118 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2119 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2120 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2121 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2122 io_analog[0] ina_top_0.VB1 a_436794_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2123 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2124 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2125 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2126 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2127 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2128 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2129 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2130 ina_top_0.VB1 ina_top_0.VB1 a_437504_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2131 ina_top_0.VB1 ina_top_0.VB1 a_437504_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2132 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2133 ina_top_0.dda_0.VD1 gpio_noesd[6] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2134 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2135 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2136 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2137 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2138 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2139 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2140 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2141 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2142 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2143 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2144 a_436794_535042# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2145 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2146 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2147 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2148 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2149 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2150 vssa1 ina_top_0.VB2 a_444594_532060# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2151 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2152 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2153 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2154 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2155 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2156 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2157 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2158 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2159 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2160 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2161 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2162 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2163 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2164 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2165 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2166 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2167 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2168 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2169 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2170 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2171 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2172 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2173 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2174 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2175 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2176 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2177 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2178 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2179 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2180 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2181 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2182 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2183 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2184 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2185 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2186 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2187 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2188 a_435052_533673# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2189 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2190 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2191 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2192 a_436278_529985# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2193 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2194 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2195 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2196 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2197 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2198 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2199 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2200 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2201 ina_top_0.VB3 ina_top_0.VB1 a_436278_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2202 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2203 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2204 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2205 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2206 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2207 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2208 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2209 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2210 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2211 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2212 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2213 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2214 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2215 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2216 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2217 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2218 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2219 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2220 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2221 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2222 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2223 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2224 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2225 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2226 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2227 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2228 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2229 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2230 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2231 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2232 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2233 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2234 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2235 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2236 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2237 vssa1 io_analog[5] a_444594_533437# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2238 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2239 io_analog[0] ina_top_0.VB1 a_435762_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2240 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2241 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2242 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2243 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2244 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2245 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2246 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2247 a_436794_531491# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2248 a_436794_532587# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2249 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2250 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2251 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2252 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2253 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2254 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2255 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2256 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2257 ina_top_0.VB2 ina_top_0.VB1 a_437504_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2258 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2259 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2260 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2261 a_434536_537433# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2262 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2263 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2264 gpio_noesd[6] ina_top_0.VB3 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2265 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2266 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2267 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2268 vssa1 ina_top_0.VB2 a_442888_531154# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2269 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2270 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2271 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2272 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2273 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2274 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2275 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2276 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2277 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2278 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2279 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2280 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2281 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2282 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2283 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2284 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2285 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2286 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2287 a_434536_527864# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2288 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2289 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2290 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2291 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2292 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2293 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2294 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2295 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2296 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2297 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2298 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2299 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2300 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2301 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2302 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2303 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2304 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2305 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2306 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2307 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2308 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2309 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2310 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2311 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2312 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2313 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2314 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2315 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2316 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2317 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2318 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2319 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2320 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2321 gpio_noesd[6] ina_top_0.VB3 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2322 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2323 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2324 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2325 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2326 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2327 ina_top_0.VB1 ina_top_0.VB1 a_437504_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2328 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2329 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2330 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2331 vssa1 ina_top_0.VB2 a_441182_532060# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2332 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2333 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2334 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2335 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2336 vssa1 io_analog[5] a_444594_532532# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2337 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2338 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2339 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2340 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2341 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2342 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2343 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2344 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2345 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2346 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2347 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2348 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2349 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2350 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2351 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2352 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2353 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2354 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2355 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2356 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2357 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2358 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2359 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2360 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2361 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2362 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2363 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2364 a_437504_535042# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2365 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2366 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2367 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2368 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2369 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2370 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2371 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2372 a_435052_529985# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2373 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2374 io_analog[0] ina_top_0.VB1 a_438020_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2375 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2376 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2377 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2378 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2379 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2380 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2381 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2382 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
D4 vssa1 io_analog[3] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X2383 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2384 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2385 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2386 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2387 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2388 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2389 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2390 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2391 a_436794_534421# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2392 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2393 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2394 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2395 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2396 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2397 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2398 io_analog[0] ina_top_0.VB1 a_438020_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2399 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2400 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2401 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2402 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2403 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2404 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2405 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2406 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2407 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2408 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2409 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2410 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2411 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2412 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2413 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2414 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2415 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2416 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2417 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2418 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2419 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2420 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2421 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2422 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2423 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2424 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2425 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2426 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2427 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2428 a_438020_537433# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2429 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2430 a_436278_533052# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2431 vssa1 io_analog[5] a_441182_533437# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2432 ina_top_0.dda_0.VIT_N2 gpio_noesd[5] ina_top_0.dda_0.VD2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2433 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2434 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2435 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2436 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2437 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2438 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2439 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2440 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2441 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2442 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2443 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2444 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2445 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2446 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2447 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2448 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2449 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2450 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2451 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2452 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2453 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2454 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2455 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2456 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2457 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2458 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2459 a_438020_527864# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2460 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2461 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2462 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2463 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2464 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2465 a_436794_531958# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2466 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2467 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2468 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2469 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2470 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2471 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2472 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2473 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2474 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2475 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2476 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2477 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2478 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2479 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2480 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2481 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2482 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2483 a_437504_531491# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2484 a_437504_532587# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2485 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2486 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2487 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2488 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2489 a_436278_536546# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2490 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2491 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2492 io_analog[0] ina_top_0.VB1 a_435762_533052# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2493 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2494 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2495 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2496 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2497 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2498 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2499 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2500 ina_top_0.VB1 io_analog[5] a_443741_531154# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2501 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2502 ina_top_0.VB2 ina_top_0.VB1 a_436278_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2503 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2504 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2505 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2506 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2507 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2508 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2509 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2510 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2511 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2512 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2513 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2514 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2515 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2516 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2517 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2518 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2519 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2520 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2521 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2522 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2523 a_436278_530872# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2524 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2525 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2526 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2527 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2528 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2529 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2530 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2531 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2532 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2533 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2534 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2535 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2536 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2537 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2538 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2539 ina_top_0.dda_0.VIT_N1 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2540 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2541 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2542 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2543 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2544 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2545 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2546 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2547 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2548 vssa1 io_analog[5] a_441182_532532# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2549 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2550 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2551 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2552 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2553 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2554 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2555 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2556 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2557 io_analog[0] ina_top_0.VB1 a_435762_536546# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2558 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2559 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2560 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2561 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2562 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2563 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2564 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2565 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2566 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2567 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2568 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2569 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2570 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2571 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2572 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2573 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2574 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2575 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2576 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2577 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2578 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2579 io_analog[0] ina_top_0.VB1 a_436794_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2580 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2581 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2582 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2583 io_analog[5] io_analog[5] a_442035_532060# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2584 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2585 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2586 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2587 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2588 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2589 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2590 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2591 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2592 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2593 io_analog[0] ina_top_0.VB1 a_435762_530872# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2594 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2595 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2596 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2597 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2598 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2599 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2600 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2601 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2602 io_analog[0] ina_top_0.VB1 a_436794_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2603 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2604 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2605 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2606 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2607 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2608 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2609 a_443569_537247# ina_top_0.VB4 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2610 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2611 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2612 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2613 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2614 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2615 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2616 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2617 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2618 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2619 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2620 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2621 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2622 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2623 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2624 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2625 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2626 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2627 ina_top_0.VB1 ina_top_0.VB1 a_436278_531491# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2628 ina_top_0.VB1 ina_top_0.VB1 a_436278_532587# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2629 ina_top_0.VB3 ina_top_0.VB1 a_437504_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2630 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2631 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2632 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2633 a_435052_533052# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2634 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2635 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2636 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2637 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
D5 vssa1 io_analog[5] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X2638 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2639 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2640 a_437504_534421# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2641 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2642 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2643 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2644 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2645 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2646 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2647 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2648 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2649 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2650 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2651 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2652 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2653 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2654 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2655 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2656 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2657 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2658 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2659 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2660 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2661 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2662 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2663 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2664 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2665 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2666 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2667 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2668 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2669 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2670 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2671 ina_top_0.VB4 ina_top_0.VB4 a_443827_537711# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2672 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2673 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2674 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2675 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2676 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2677 ina_top_0.VB4 ina_top_0.VB2 a_442035_533437# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2678 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2679 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2680 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2681 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2682 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2683 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2684 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2685 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2686 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2687 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2688 a_435052_536546# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2689 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2690 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2691 a_443741_532060# io_analog[5] vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2692 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2693 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2694 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2695 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2696 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2697 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2698 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2699 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2700 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2701 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2702 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2703 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2704 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2705 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2706 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2707 gpio_noesd[6] ina_top_0.VB3 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2708 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2709 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2710 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2711 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2712 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2713 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2714 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2715 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2716 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2717 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2718 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2719 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2720 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2721 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2722 a_437504_531958# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2723 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2724 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2725 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2726 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2727 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2728 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2729 a_435052_530872# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2730 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2731 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2732 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2733 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2734 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2735 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2736 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2737 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2738 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2739 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2740 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2741 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2742 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2743 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2744 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2745 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2746 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2747 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2748 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2749 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2750 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2751 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2752 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2753 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2754 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2755 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2756 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2757 ina_top_0.dda_0.SUM_N ina_top_0.VB3 gpio_noesd[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2758 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2759 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2760 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2761 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2762 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2763 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2764 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2765 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2766 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2767 ina_top_0.VB2 ina_top_0.VB1 a_437504_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2768 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2769 a_436794_529368# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2770 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2771 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2772 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2773 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2774 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2775 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2776 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2777 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2778 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2779 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2780 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2781 ina_top_0.VB3 ina_top_0.VB1 a_436278_534421# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2782 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2783 ina_top_0.VB2 ina_top_0.VB2 a_442035_532532# vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2784 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2785 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2786 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2787 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2788 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2789 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2790 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2791 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2792 a_443741_533437# ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2793 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2794 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2795 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2796 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2797 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2798 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2799 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2800 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2801 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2802 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2803 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2804 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2805 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2806 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2807 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2808 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2809 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2810 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2811 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2812 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2813 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2814 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2815 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2816 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2817 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2818 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2819 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2820 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2821 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2822 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2823 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2824 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2825 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2826 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2827 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2828 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2829 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2830 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2831 a_442035_531154# io_analog[5] vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2832 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2833 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2834 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2835 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2836 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2837 a_435762_533673# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2838 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2839 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2840 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2841 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2842 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2843 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2844 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2845 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2846 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2847 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2848 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2849 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2850 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2851 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2852 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2853 ina_top_0.VB1 ina_top_0.VB1 a_436278_531958# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2854 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2855 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2856 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2857 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2858 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2859 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2860 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2861 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2862 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2863 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2864 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2865 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2866 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2867 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2868 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2869 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2870 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2871 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2872 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2873 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2874 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2875 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2876 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2877 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2878 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2879 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2880 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2881 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2882 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2883 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2884 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2885 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2886 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2887 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2888 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2889 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2890 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2891 a_443741_532532# ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2892 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2893 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2894 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2895 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2896 a_436794_535929# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2897 ina_top_0.dda_0.VD1 gpio_noesd[6] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
D6 vssa1 io_analog[2] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X2898 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2899 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2900 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2901 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2902 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2903 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2904 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2905 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2906 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2907 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2908 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2909 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2910 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2911 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2912 a_444594_532060# ina_top_0.VB2 ina_top_0.VB2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2913 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2914 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2915 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2916 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2917 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2918 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2919 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2920 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2921 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2922 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2923 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2924 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2925 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2926 io_analog[0] ina_top_0.VB1 a_435052_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2927 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2928 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2929 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2930 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2931 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2932 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2933 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2934 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2935 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2936 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2937 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2938 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2939 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2940 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2941 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2942 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2943 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2944 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2945 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2946 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2947 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2948 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2949 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2950 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2951 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2952 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2953 ina_top_0.VB1 ina_top_0.VB1 a_434536_533673# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2954 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2955 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2956 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2957 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2958 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2959 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2960 ina_top_0.VB4 ina_top_0.VB4 a_443827_536177# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2961 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2962 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2963 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2964 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2965 a_436278_528481# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2966 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2967 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2968 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2969 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2970 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2971 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2972 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2973 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2974 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2975 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2976 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2977 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2978 a_441182_531154# ina_top_0.VB2 ina_top_0.VB4 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2979 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2980 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2981 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2982 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2983 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2984 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2985 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2986 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X2987 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2988 a_437504_529368# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X2989 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2990 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2991 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2992 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2993 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2994 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2995 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2996 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X2997 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X2998 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X2999 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3000 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3001 ina_top_0.dda_0.VIT_N2 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3002 a_444594_533437# io_analog[5] ina_top_0.VB1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3003 a_435762_529985# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3004 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3005 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3006 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3007 io_analog[0] ina_top_0.VB1 a_435762_528481# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3008 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3009 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3010 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3011 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3012 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3013 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3014 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3015 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3016 a_443827_537711# ina_top_0.VB4 a_443569_537711# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3017 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3018 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3019 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3020 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3021 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3022 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3023 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3024 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3025 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3026 a_442888_531154# ina_top_0.VB2 ina_top_0.VB4 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3027 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3028 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3029 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3030 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3031 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3032 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3033 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3034 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3035 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3036 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3037 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3038 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3039 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3040 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3041 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3042 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3043 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3044 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3045 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3046 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3047 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3048 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3049 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3050 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3051 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3052 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3053 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3054 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3055 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3056 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3057 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3058 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3059 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3060 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3061 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3062 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3063 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3064 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3065 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3066 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3067 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3068 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3069 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3070 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3071 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3072 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3073 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3074 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3075 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3076 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3077 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
D7 vssa1 io_analog[4] sky130_fd_pr__diode_pw2nd_05v5 pj=1.8e+06 area=2.025e+11
X3078 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3079 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3080 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3081 ina_top_0.dda_0.SUM_P ina_top_0.VB3 gpio_noesd[6] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3082 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3083 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3084 ina_top_0.dda_0.VIT_N2 gpio_noesd[5] ina_top_0.dda_0.VD2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3085 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3086 ina_top_0.dda_0.VIT_P2 io_analog[1] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3087 a_444594_532532# io_analog[5] io_analog[5] vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3088 gpio_noesd[5] ina_top_0.VB3 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3089 io_analog[0] ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3090 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3091 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3092 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3093 io_analog[0] ina_top_0.VB1 a_435052_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3094 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3095 a_437504_535929# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3096 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3097 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3098 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3099 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3100 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3101 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3102 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3103 ina_top_0.VB2 ina_top_0.VB1 a_436278_529368# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3104 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3105 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3106 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3107 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3108 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3109 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3110 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3111 ina_top_0.dda_0.VIT_P1 io_analog[3] ina_top_0.dda_0.SUM_N io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3112 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3113 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3114 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3115 ina_top_0.VB2 ina_top_0.VB1 a_434536_529985# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3116 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3117 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3118 ina_top_0.dda_0.VD6 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3119 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3120 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3121 a_435052_528481# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3122 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3123 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3124 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3125 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3126 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3127 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3128 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3129 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3130 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3131 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3132 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3133 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3134 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3135 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3136 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3137 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3138 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3139 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3140 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3141 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3142 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3143 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3144 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3145 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3146 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3147 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3148 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3149 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3150 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3151 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3152 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3153 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3154 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3155 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3156 ina_top_0.VB2 ina_top_0.VB1 a_437504_537433# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3157 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3158 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3159 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3160 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3161 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3162 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3163 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3164 gpio_noesd[5] ina_top_0.VB4 ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3165 ina_top_0.dda_0.SUM_P ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3166 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3167 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3168 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3169 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3170 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3171 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3172 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3173 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3174 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3175 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3176 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3177 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3178 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3179 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3180 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3181 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_N vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3182 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3183 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3184 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3185 ina_top_0.VB3 ina_top_0.VB1 a_437504_527864# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3186 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3187 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3188 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3189 ina_top_0.dda_0.VD1 ina_top_0.dda_0.VD1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3190 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3191 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3192 ina_top_0.dda_0.VD5 ina_top_0.VB4 gpio_noesd[6] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3193 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3194 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3195 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3196 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3197 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3198 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3199 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3200 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3201 io_analog[0] ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3202 ina_top_0.dda_0.SUM_N io_analog[1] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3203 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3204 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3205 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3206 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3207 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3208 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3209 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3210 ina_top_0.VB3 ina_top_0.VB1 a_436278_535929# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3211 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3212 vssa1 ina_top_0.VB2 ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3213 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3214 ina_top_0.dda_0.VIT_N1 ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3215 a_435762_533052# ina_top_0.VB1 ina_top_0.VB1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3216 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3217 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3218 ina_top_0.dda_0.SUM_N io_analog[3] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3219 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3220 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3221 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3222 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3223 a_436278_535042# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3224 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3225 ina_top_0.dda_0.SUM_N ina_top_0.VB2 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3226 ina_top_0.dda_0.VIT_N2 gpio_noesd[4] ina_top_0.dda_0.VCMFB vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3227 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3228 ina_top_0.dda_0.VIT_P1 io_analog[4] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3229 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3230 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3231 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3232 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3233 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3234 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3235 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3236 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3237 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3238 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3239 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3240 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3241 ina_top_0.dda_0.VIT_P2 io_analog[2] ina_top_0.dda_0.SUM_P io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3242 ina_top_0.dda_0.VD2 gpio_noesd[5] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3243 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3244 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3245 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3246 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3247 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3248 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3249 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3250 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3251 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3252 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3253 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3254 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3255 ina_top_0.dda_0.SUM_P io_analog[2] ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3256 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3257 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3258 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3259 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3260 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3261 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3262 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3263 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3264 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3265 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3266 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3267 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3268 ina_top_0.dda_0.VD5 ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3269 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3270 ina_top_0.dda_0.VIT_N1 gpio_noesd[6] ina_top_0.dda_0.VD1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3271 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3272 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3273 a_435762_536546# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3274 a_434536_533673# ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3275 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3276 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3277 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3278 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3279 io_analog[0] ina_top_0.VB1 a_435762_535042# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3280 a_443827_536177# ina_top_0.VB4 a_443569_536177# io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3281 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3282 vssa1 ina_top_0.VB2 ina_top_0.dda_0.SUM_P vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3283 ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3284 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3285 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VD6 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3286 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3287 a_436794_537433# ina_top_0.VB1 ina_top_0.VB3 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3288 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3289 ina_top_0.dda_0.SUM_P io_analog[4] ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3290 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3291 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3292 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3293 ina_top_0.dda_0.VIT_P1 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3294 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3295 a_435762_530872# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3296 ina_top_0.dda_0.VIT_N2 gpio_noesd[5] ina_top_0.dda_0.VD2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3297 io_analog[0] ina_top_0.dda_0.VCMFB ina_top_0.dda_0.VCMFB io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3298 ina_top_0.dda_0.VIT_N2 gpio_noesd[5] ina_top_0.dda_0.VD2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3299 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3300 ina_top_0.dda_0.VIT_P2 ina_top_0.VB1 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3301 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3302 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.29 ps=2.58 w=1 l=1
X3303 gpio_noesd[6] ina_top_0.VB4 ina_top_0.dda_0.VD5 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3304 ina_top_0.dda_0.VD2 ina_top_0.dda_0.VD2 io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3305 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3306 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3307 a_436794_527864# ina_top_0.VB1 ina_top_0.VB2 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3308 ina_top_0.dda_0.VD6 ina_top_0.VB4 gpio_noesd[5] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3309 io_analog[0] ina_top_0.VB1 ina_top_0.dda_0.VIT_P1 io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.145 ps=1.29 w=1 l=1
X3310 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3311 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3312 vssa1 vssa1 vssa1 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3313 ina_top_0.dda_0.VCMFB gpio_noesd[4] ina_top_0.dda_0.VIT_N2 vssa1 sky130_fd_pr__nfet_01v8 ad=0.29 pd=2.58 as=0.145 ps=1.29 w=1 l=1
X3314 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
X3315 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0 ps=0 w=1 l=1
X3316 io_analog[0] io_analog[0] io_analog[0] io_analog[0] sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0 ps=0 w=1 l=1
.ends
